# Keil uVision project melody.uvproj, settings and files
target melody (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: melody +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: STARTUP.A51 main.c tones.h music.h
  group tones
    ./: tones.c
  group music
    ./: music.c
